options:
  parameters:
    author: Codrina Lisaru
    generate_options: qt_gui
    id: Mono_Stereo_FM_Receiver
    output_language: python
    title: 'Apl.2: FM Mono/Stereo Receiver'
  states: {}

blocks:
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: RF Gain in dB
    orient: Qt.Vertical
    start: '0'
    step: '1'
    stop: '50'
    value: '22.9'
  states: {}
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Frequency in Hz
    orient: Qt.Horizontal
    start: 87e6
    step: 100e3
    stop: 108e6
    value: 101.8e6
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: uiselect
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: 'Receiver Configuration:'
    label0: Monophonic FM Receiver
    label1: Stereo FM Receiver
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: real
    value: '0'
  states: {}
- name: uiselect2
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: Mono Receiver Options
    label0: Listen without recording
    label1: Listen and record
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: real
    value: '0'
  states: {}
- name: uiselect3
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label: Stereo Receiver Options
    label0: Listen without recording
    label1: Listen and record
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: real
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec
    quad_rate: quadrature
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: uiselect
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: uiselect2
    type: float
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: uiselect3
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: M:\OneDrive\02_Master\2_2\02_Disertatie\GNU Radio implementation\Aplicatia 2 - Receptor FM Mono Stereo\Mono_recorder.wav
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: M:\OneDrive\02_Master\2_2\02_Disertatie\GNU Radio implementation\Aplicatia 2 - Receptor FM Mono Stereo\Stereo_recorder.wav
    nchan: '2'
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tab_widget@4
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: tab_widget@0
    name: Raw Frequency Representation
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: tab_widget@1
    name: 'Frequency domain representation for Stereo '
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-180'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: tab_widget@1
    name: Frequency domain representation for Monophonic reception
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-180'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tab_widget@2
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab_widget@2
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: tab_widget@3
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/quadrature)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/quadrature)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature/1e3/audio_dec)
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: RF_Gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: tab_widget
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,3
    label0: Raw Frequency Representation
    label1: Frequency Domain
    label2: Time Domain
    label3: 'Waterfall '
    label4: Constellation
    num_tabs: '5'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_wfm_rcv_pll_0, '0', qtgui_time_sink_x_0, '1']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_wfm_rcv_pll_0, '1', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_rcv_pll_0, '1', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0_0, '1']
- [blocks_complex_to_float_0_0, '0', audio_sink_0_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_wavfile_sink_1, '0']
- [blocks_complex_to_float_0_0, '1', audio_sink_0_0_0, '1']
- [blocks_complex_to_float_0_0, '1', blocks_wavfile_sink_1, '1']
- [blocks_float_to_complex_0, '0', blocks_selector_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_0_0, '0']
- [blocks_selector_1, '0', audio_sink_0_1, '0']
- [blocks_selector_1, '1', audio_sink_0, '0']
- [blocks_selector_1, '1', blocks_wavfile_sink_0, '0']
- [blocks_selector_2, '0', blocks_complex_to_float_0, '0']
- [blocks_selector_2, '1', blocks_complex_to_float_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_0, '0', analog_wfm_rcv_pll_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', blocks_selector_0, '0']
- [rtlsdr_source_0, '0', qtgui_const_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
